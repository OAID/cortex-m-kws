# Keil uVision project Project.uvprojx, settings and files
target STM32469I_DISCOVERY (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F469NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2004FFFF) IRAM2(0x10000000-0x2000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32469I_DISCO_AID +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F469xx
  c misc: -DARM_MATH_CM4 -D__FPU_PRESENT -DUSE_USB_FS -DUSE_STM32469I_DISCOVERY -DTS_MULTI_TOUCH_SUPPORTED -DFIXED_POINT
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32469I-Discovery;../../../../../../Drivers/BSP/Components/Common;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../../Utilities;../../../../../../Utilities/Log;../../../../../../Utilities/Fonts;../../../../../../Utilities/CPU;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;../../../../../../Middlewares/Third_Party/FatFs/src;../../../../../../Middlewares/Third_Party/resample;..\..\..\..\..\..\tengine-lite\include;..\..\..\..\..\..\tengine-lite\src\serializer\tiny
  asm include: ROJ_DIR$\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xa000000
  link misc: --diag_suppress=L6329
  group Middlewares/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: queue.c timers.c list.c tasks.c
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/FatFs
    ../../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/STM32_USBH_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group Middlewares/STM32_USBH_Library/Class/MSC
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group Middlewares/PDM
    ../../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Lib/: libPDMFilter_CM4_Keil_wc16.lib
  group Drivers/BSP/STM32469I-Discovery
    ../../../../../../Drivers/BSP/STM32469I-Discovery/: stm32469i_discovery.c stm32469i_discovery_audio.c stm32469i_discovery_lcd.c stm32469i_discovery_sdram.c stm32469i_discovery_ts.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_i2c.c stm32f4xx_hal_tim.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_rcc.c stm32f4xx_hal_uart.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dsi.c stm32f4xx_hal_i2s.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_sdram.c stm32f4xx_ll_fmc.c stm32f4xx_ll_usb.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_sram.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sai.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/ft6x06/: ft6x06.c
    ../../../../../../Drivers/BSP/Components/otm8009a/: otm8009a.c
    ../../../../../../Drivers/BSP/Components/cs43l22/: cs43l22.c
  group Example/MDK-ARM
    ./: startup_stm32f469xx.s
  group Example/User
    ../Src/: stm32f4xx_hal_timebase_tim.c stm32f4xx_it.c main.c ts_calibration.c usbh_conf.c usbh_diskio_dma.c test.c explorer.c waveplayer.c waverecorder.c uart.c
  group Utilities
    ../../../../../../Utilities/Log/: lcd_log.c
  group aid
    ../Src/: mfcc.c command_recognition.c tengine_task.c arm_convolve_HWC_q7_nonsquare.c arm_maxpool_HWC_q7_nonsquare.c
  group resample
    ../../../../../../Middlewares/Third_Party/resample/: resample.c
  group Tengine
    ../../../../../../tengine-lite/src/dev/cpu/: cpu_device.c cpu_module.c cpu_node_ops.c cpu_probe.c
    ../../../../../../tengine-lite/src/dev/cpu/op/conv/: conv_cmsis.c
    ../../../../../../tengine-lite/src/dev/cpu/op/fc/: fc_cmsis.c
    ../../../../../../tengine-lite/src/dev/cpu/op/mv/: mv_cmsis.c
    ../../../../../../tengine-lite/src/dev/cpu/op/pooling/: pooling_cmsis.c
    ../../../../../../tengine-lite/src/dev/cpu/op/relu/: relu_cmsis.c
    ../../../../../../tengine-lite/src/dev/cpu/op/softmax/: softmax_cmsis.c
    ../../../../../../tengine-lite/src/lib/: buddy_mem.c dev_allocator.c exec_scheduler.c hash.c hash_impl.c map.c mem_stat.c module.c nn_device.c sys_port.c tengine_c_api.c tengine_errno.c tengine_exec.c tengine_ir.c tengine_log.c tengine_op.c tengine_serializer.c tengine_utils.c vector.c
    ../../../../../../tengine-lite/src/op/: convolution.c fc.c mv_op.c pooling.c simple_op.c relu.c
    ../../../../../../tengine-lite/src/serializer/tiny/: tiny_serializer.c
    ../../../../../../tengine-lite/tests/bin/tiny/: tiny_graph_generated.c
software components: CMSIS:CORE 5.1.2, CMSIS:DSP 1.5.2, CMSIS:NN Lib 1.1.0
