# Keil uVision project Tengine-Project.uvprojx, settings and files
target Tengine-Demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: DemoProject +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F769xx,USE_STM32F769I_DISCO
  c misc: -DARM_MATH_CM7 -D__FPU_PRESENT
  c include: ../Inc;../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../Drivers/STM32F7xx_HAL_Driver/Inc;../../Drivers/BSP/STM32F769I-Discovery;../../Drivers/BSP/Components;../../Utilities;../../Utilities/fonts;../../Middlewares/Third_Party/FatFs/src;../../Middlewares/Third_Party/FatFs/src/drivers;../../tengine-lite\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group Middlewares/FatFs/Drivers
    ../Src/: sd_diskio.c
  group Middlewares/FatFs/Core
    ../../Middlewares/Third_Party/FatFs/src/: ff.c diskio.c ff_gen_drv.c
  group Application/User
    ../Src/: main.c stm32f7xx_it.c fatfs_storage.c arm_convolve_HWC_q7_nonsquare.c arm_pooling_HWC_q7_nonsquare.c print.c mfcc.c
  group Application/MDK-ARM
    ./: startup_stm32f769xx.s
  group Drivers/BSP/Components
    ../../Drivers/BSP/Components/otm8009a/: otm8009a.c
  group Drivers/BSP/STM32F769I_Discovery
    ../../Drivers/BSP/STM32F769I-Discovery/: stm32f769i_discovery.c stm32f769i_discovery_sd.c stm32f769i_discovery_lcd.c stm32f769i_discovery_sdram.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Middlewares/FatFs/Option
    ../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Doc
    ../: readme.txt
  group Drivers/STM32F7xx_HAL_Driver
    ../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_uart.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_ltdc.c stm32f7xx_ll_fmc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_i2c.c stm32f7xx_hal_pwr.c stm32f7xx_hal_dma.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_gpio.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_dsi.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_sd.c
  group Tengine-lite
    ../../tengine-lite/src/dev/cpu/: cpu_device.c cpu_module.c cpu_node_ops.c cpu_probe.c
    ../../tengine-lite/src/dev/cpu/op/conv/: conv_cmsis.c
    ../../tengine-lite/src/dev/cpu/op/fc/: fc_cmsis.c
    ../../tengine-lite/src/dev/cpu/op/pooling/: pooling_cmsis.c
    ../../tengine-lite/src/dev/cpu/op/relu/: relu_cmsis.c
    ../../tengine-lite/src/dev/cpu/op/softmax/: softmax_cmsis.c
    ../../tengine-lite/src/lib/: buddy_mem.c dev_allocator.c exec_scheduler.c hash.c hash_impl.c map.c mem_stat.c module.c nn_device.c sys_port.c tengine_c_api.c tengine_errno.c tengine_exec.c tengine_ir.c tengine_log.c tengine_op.c tengine_serializer.c tengine_utils.c vector.c
    ../../tengine-lite/src/op/: convolution.c fc.c pooling.c simple_op.c
    ../../tengine-lite/src/serializer/tiny/: tiny_serializer.c
    ../../tengine-lite/tests/bin/tiny/: tiny_graph_generated.c stm32f7_test.c
software components: CMSIS:CORE 5.1.1, CMSIS:DSP 1.5.2, CMSIS:NN Lib 1.0.0
